# Keil uVision project BordBal.uvprojx, settings and files
target F407VE (6120000::V6.12::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BordBal
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: STM32F407xx
  c include: .\External\LCD;.\External\OV2640;.\Users\ImageProcess;.\Users\TimeBase;.\External\MOTO;.\Inside\pid
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1bfff
  memory RVCT10: RAM 0x10000000 size 0xffff
  scatter file: .\Inside\BordBal.sct
  group Users
    ./Users/: main.c IRQHandler.c
    ./Users/TimeBase/: TimeBase.c
    ./Users/ImageProcess/: ImageProcess.c
  group Inside
    ./Inside/pid/: pid.c
  group External
    ./External/LCD/: LCD.c
    ./External/OV2640/: OV2640.c SCCB.c
    ./External/MOTO/: MOTO.c
software components: RTOS:Config 10.2.0, RTOS:Core 10.0.1, RTOS:Event Groups 10.0.1, RTOS:Heap 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.2.0, CMSIS:RTOS2:FreeRTOS 10.0.1, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DCMI 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:SRAM 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:Startup 2.6.2
